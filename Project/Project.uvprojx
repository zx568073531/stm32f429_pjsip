# Keil uVision project Project.uvprojx, settings and files
target WorkStation (6180000::V6.18::ARMCLANG)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx,__TARGET_FPU_VFP,__FPU_PRESENT=1U,ARM_MATH_LOOPUNROLL,PJ_ARM=1,SPEEX_CONFIG_H,
  c include: ..\SystemCore;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Include;..\UserApplication\UserMainEntry;..\Middlewares\tinyusb\src;..\Middlewares\tinyusb\src\portable\st\stm32_fsdev;..\Middlewares\tinyusb\src\portable\st\synopsys;..\Middlewares\tinyusb\src\osal;..\Middlewares\tinyusb\src\host;..\Middlewares\tinyusb\src\device;..\Middlewares\tinyusb\src\common;..\Middlewares\tinyusb\src\class\cdc;..\Middlewares\tinyusb\src\class\msc;..\UserApplication\UserTinyUSBPort;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable\GCC\ARM_CM4F;..\Middlewares\FreeRTOS\portable\MemMang;..\Middlewares\Fatfs\source;..\UserApplication\UserFatfsPort;..\UserApplication\UserFreeRTOSPort;..\Middlewares\FreeRTOS_POSIX\include;..\Middlewares\FreeRTOS_POSIX\include\private;..\Middlewares\FreeRTOS_POSIX\include\FreeRTOS_POSIX;..\Middlewares\FreeRTOS_POSIX\FreeRTOS-Plus-POSIX\include;..\Middlewares\FreeRTOS_POSIX\FreeRTOS-Plus-POSIX\include\portable;..\Middlewares\FreeRTOS_POSIX\FreeRTOS-Plus-POSIX\include\portable\st\stm32l475_discovery;..\Middlewares\CycloneTCP_SSL_SSH_CRYPTO_Open_2_1_4\cyclone_port;..\Middlewares\CycloneTCP_SSL_SSH_CRYPTO_Open_2_1_4\common;..\Middlewares\CycloneTCP_SSL_SSH_CRYPTO_Open_2_1_4\cyclone_tcp;..\Middlewares\CycloneTCP_SSL_SSH_CRYPTO_Open_2_1_4\cyclone_ssh;..\Middlewares\CycloneTCP_SSL_SSH_CRYPTO_Open_2_1_4\cyclone_crypto;..\Periperhal;..\Middlewares\SEGGER_RTT_V680e\RTT;..\Middlewares\pjproject\pjlib\include;..\Middlewares\pjproject\pjlib-util\include;..\Middlewares\pjproject\pjmedia\include;..\Middlewares\pjproject\pjnath\include;..\Middlewares\pjproject\pjsip\include;..\Middlewares\pjproject\third_party\resample\include;..\Middlewares\pjproject\third_party;..\Middlewares\pjproject\third_party\speex\libspeex;..\Middlewares\pjproject\third_party\speex\include;..\Middlewares\pjproject\third_party\speex;..\Middlewares\pjproject\third_party\g7221\common;..\Middlewares\pjproject;..\Middlewares\pjproject\third_party\ilbc;..\Middlewares\pjproject\third_party\gsm\inc;..\Middlewares\CmBacktrace\cm_backtrace
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0xc0000000 size 0x1000000
  memory RVCT9: RAM 0x20000000 size 0x15000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User/Application
    ../UserApplication/UserMainEntry/: task_main.c task_usb.c task_ssh.c task_network.c
  group System/User
    ../SystemCore/: systemMain.c systemISR.c systemClock.c systemCommon.c systemCompont.c systemLog.c systemTime.c systemTick.c retarget.c
  group System/Core
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group System/HAL Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group Middlewares/TinyUSB
    ../Middlewares/tinyusb/src/: tusb.c
    ../Middlewares/tinyusb/src/portable/st/stm32_fsdev/: dcd_stm32_fsdev.c
    ../Middlewares/tinyusb/src/portable/st/synopsys/: dcd_synopsys.c
    ../Middlewares/tinyusb/src/host/: hub.c usbh.c usbh_control.c
    ../Middlewares/tinyusb/src/device/: usbd.c usbd_control.c
    ../Middlewares/tinyusb/src/common/: tusb_fifo.c
    ../Middlewares/tinyusb/src/class/cdc/: cdc_device.c cdc_host.c cdc_rndis_host.c
    ../Middlewares/tinyusb/src/class/msc/: msc_device.c msc_host.c
  group Middlewares/TinyUSB/Port
    ../UserApplication/UserTinyUSBPort/: tusb_config.h msc_disk.c usb_descriptors.c freertos_hook.c
  group Middlewares/FreeRTOS
    ../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/FreeRTOS/portable/MemMang/: heap_5.c
    ../Middlewares/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
  group Middlewares/FreeRTOS/port
    ../Middlewares/FreeRTOS/include/: FreeRTOSConfig.h
  group Middlewares/Fatfs
    ../Middlewares/Fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group Middlewares/Fatfs/port
    ../UserApplication/UserFatfsPort/: user_sd_init.c ff_gen_drv.c sd_diskio_dma_rtos.c stm324x9i_eval_sd.c
  group Middlewares/FreeRTOS/Posix
    ../Middlewares/FreeRTOS_POSIX/FreeRTOS-Plus-POSIX/source/: FreeRTOS_POSIX_clock.c FreeRTOS_POSIX_mqueue.c FreeRTOS_POSIX_pthread.c FreeRTOS_POSIX_pthread_barrier.c FreeRTOS_POSIX_pthread_cond.c FreeRTOS_POSIX_pthread_mutex.c FreeRTOS_POSIX_pthread_key.c FreeRTOS_POSIX_sched.c FreeRTOS_POSIX_semaphore.c FreeRTOS_POSIX_timer.c FreeRTOS_POSIX_unistd.c FreeRTOS_POSIX_utils.c FreeRTOS_POSIX_pthread_rwlock.c
  group User/Periperhal
    ../Periperhal/: bsp_myiic.c pcf8574.c wm8978.c sdram.c bsp_i2s.c bsp_sai.c audio.c
  group Middlewares/cyclone/common
    ../Middlewares/CycloneTCP_SSL_SSH_CRYPTO_Open_2_1_4/common/: cpu_endian.c date_time.c debug.c fs_port_fatfs.c path.c resource_manager.c str.c os_port_freertos.c
  group Middlewares/cyclone/cyclone_tcp/core
    ../Middlewares/CycloneTCP_SSL_SSH_CRYPTO_Open_2_1_4/cyclone_tcp/core/: bsd_socket.c bsd_socket_misc.c ethernet.c ethernet_misc.c ip.c net.c net_mem.c net_misc.c nic.c ping.c raw_socket.c socket.c socket_misc.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c
  group Middlewares/cyclone/cyclone_tcp/dhcp
    ../Middlewares/CycloneTCP_SSL_SSH_CRYPTO_Open_2_1_4/cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c dhcp_server.c dhcp_server_misc.c
    ../Middlewares/CycloneTCP_SSL_SSH_CRYPTO_Open_2_1_4/cyclone_tcp/dhcpv6/: dhcpv6_client.c dhcpv6_client_fsm.c dhcpv6_client_misc.c dhcpv6_common.c dhcpv6_debug.c dhcpv6_relay.c
  group Middlewares/cyclone/cyclone_tcp/ipv4
    ../Middlewares/CycloneTCP_SSL_SSH_CRYPTO_Open_2_1_4/cyclone_tcp/ipv4/: arp.c auto_ip.c auto_ip_misc.c icmp.c ipv4.c ipv4_frag.c ipv4_misc.c
  group Middlewares/cyclone/cyclone_tcp/igmp
    ../Middlewares/CycloneTCP_SSL_SSH_CRYPTO_Open_2_1_4/cyclone_tcp/igmp/: igmp_common.c igmp_host.c igmp_host_misc.c igmp_router.c igmp_router_misc.c igmp_snooping.c igmp_snooping_misc.c
  group Middlewares/cyclone/cyclone_tcp/ipv6
    ../Middlewares/CycloneTCP_SSL_SSH_CRYPTO_Open_2_1_4/cyclone_tcp/ipv6/: icmpv6.c ipv6.c ipv6_frag.c ipv6_misc.c ipv6_pmtu.c ipv6_routing.c mld.c ndp.c ndp_cache.c ndp_misc.c ndp_router_adv.c ndp_router_adv_misc.c slaac.c slaac_misc.c
  group Middlewares/cyclone/cyclone_tcp/netbios
    ../Middlewares/CycloneTCP_SSL_SSH_CRYPTO_Open_2_1_4/cyclone_tcp/netbios/: nbns_client.c nbns_common.c nbns_responder.c
  group Middlewares/cyclone/cyclone_tcp/llmnr
    ../Middlewares/CycloneTCP_SSL_SSH_CRYPTO_Open_2_1_4/cyclone_tcp/llmnr/: llmnr_client.c llmnr_common.c llmnr_responder.c
  group Middlewares/cyclone/cyclone_tcp/net_driver
    ../Middlewares/CycloneTCP_SSL_SSH_CRYPTO_Open_2_1_4/cyclone_tcp/drivers/phy/: lan8720_driver.c
    ../Middlewares/CycloneTCP_SSL_SSH_CRYPTO_Open_2_1_4/cyclone_tcp/drivers/mac/: stm32f4xx_eth_driver.c
  group Middlewares/cyclone/cyclone_tcp/websocket
    ../Middlewares/CycloneTCP_SSL_SSH_CRYPTO_Open_2_1_4/cyclone_tcp/web_socket/: web_socket.c web_socket_auth.c web_socket_frame.c web_socket_misc.c web_socket_transport.c
  group Middlewares/cyclone/cyclone_tcp/dns
    ../Middlewares/CycloneTCP_SSL_SSH_CRYPTO_Open_2_1_4/cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../Middlewares/CycloneTCP_SSL_SSH_CRYPTO_Open_2_1_4/cyclone_tcp/dns_sd/: dns_sd.c
  group Middlewares/cyclone/cyclone_tcp/resource_manager
    ../Middlewares/CycloneTCP_SSL_SSH_CRYPTO_Open_2_1_4/cyclone_port/: res.c
  group Middlewares/Segger/rtt_viewer
    ../Middlewares/SEGGER_RTT_V680e/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Middlewares/pjproject/pjlib/pjlib
    ../Middlewares/pjproject/pjlib/src/pj/: activesock.c addr_resolv_sock.c array.c config.c ctype.c errno.c except.c fifobuf.c file_access_unistd.c file_io_ansi.c guid.c guid_simple.c hash.c ioqueue_select.c ip_helper_generic.c list.c lock.c log.c log_writer_stdout.c os_core_unix.c os_error_unix.c os_info.c os_time_common.c os_time_unix.c os_timestamp_common.c os_timestamp_posix.c pool.c pool_buf.c pool_caching.c pool_dbg.c pool_policy_malloc.c rand.c rbtree.c sock_bsd.c sock_common.c sock_qos_bsd.c sock_qos_common.c sock_select.c ssl_sock_common.c ssl_sock_dump.c ssl_sock_ossl.c string.c symbols.c timer.c types.c
  group Middlewares/pjproject/pjlib_util/pjlib_util
    ../Middlewares/pjproject/pjlib-util/src/pjlib-util/: base64.c cli.c cli_console.c cli_telnet.c crc32.c dns.c dns_dump.c dns_server.c errno.c getopt.c hmac_md5.c hmac_sha1.c http_client.c json.c md5.c pcap.c resolver.c scanner.c sha1.c srv_resolver.c string.c stun_simple.c stun_simple_client.c symbols.c xml.c
  group Middlewares/pjproject/pjmedia/pjmedia
    ../Middlewares/pjproject/pjmedia/src/pjmedia/: alaw_ulaw.c alaw_ulaw_table.c audiodev.c avi_player.c bidirectional.c clock_thread.c codec.c conf_switch.c conference.c converter.c converter_libswscale.c converter_libyuv.c delaybuf.c dummy.c echo_common.c echo_port.c echo_suppress.c echo_webrtc.c endpoint.c errno.c event.c ffmpeg_util.c format.c g711.c jbuf.c master_port.c mem_capture.c mem_player.c null_port.c plc_common.c port.c resample_libsamplerate.c resample_port.c resample_speex.c rtcp.c rtcp_fb.c rtcp_xr.c rtp.c sdp.c sdp_cmp.c sdp_neg.c session.c silencedet.c sound_legacy.c sound_port.c splitcomb.c stereo_port.c stream.c stream_common.c stream_info.c tonegen.c transport_adapter_sample.c transport_ice.c transport_loop.c transport_udp.c types.c wav_player.c wav_playlist.c wav_writer.c wave.c wsola.c echo_speex.c resample_resample.c
  group Middlewares/pjproject/pjmedia/pjmedia_audiodev
    ../Middlewares/pjproject/pjmedia/src/pjmedia-audiodev/: audiodev.c audiotest.c errno.c null_dev.c stm_dev.c
  group Middlewares/pjproject/pjmedia/pjmedia_codec
    ../Middlewares/pjproject/pjmedia/src/pjmedia-codec/: amr_sdp_match.c audio_codecs.c bcg729.c g722.c g7221.c g7221_sdp_match.c gsm.c ilbc.c l16.c opencore_amr.c opus.c passthrough.c silk.c speex_codec.c vpx.c vpx_packetizer.c
    ../Middlewares/pjproject/pjmedia/src/pjmedia-codec/g722/: g722_dec.c g722_enc.c
  group Middlewares/pjproject/pjnath/pjnath
    ../Middlewares/pjproject/pjnath/src/pjnath/: errno.c ice_session.c ice_strans.c nat_detect.c stun_auth.c stun_msg.c stun_msg_dump.c stun_session.c stun_sock.c stun_transaction.c turn_session.c turn_sock.c
  group Middlewares/pjproject/pjnath/pjturn_srv
    ../Middlewares/pjproject/pjnath/src/pjturn-srv/: allocation.c auth.c listener_tcp.c listener_udp.c server.c
  group Middlewares/pjproject/pjsip/pjsip
    ../Middlewares/pjproject/pjsip/src/pjsip/: sip_auth_aka.c sip_auth_client.c sip_auth_msg.c sip_auth_parser.c sip_auth_server.c sip_config.c sip_dialog.c sip_endpoint.c sip_errno.c sip_msg.c sip_multipart.c sip_parser.c sip_resolve.c sip_tel_uri.c sip_transaction.c sip_transport.c sip_transport_loop.c sip_transport_tcp.c sip_transport_tls.c sip_transport_udp.c sip_ua_layer.c sip_uri.c sip_util.c sip_util_proxy.c sip_util_statefull.c
  group Middlewares/pjproject/pjsip/pjsip_simple
    ../Middlewares/pjproject/pjsip/src/pjsip-simple/: errno.c evsub.c evsub_msg.c iscomposing.c mwi.c pidf.c presence.c presence_body.c publishc.c rpid.c xpidf.c
  group Middlewares/pjproject/pjsip/pjsip-ua
    ../Middlewares/pjproject/pjsip/src/pjsip-ua/: sip_100rel.c sip_inv.c sip_reg.c sip_replaces.c sip_timer.c sip_xfer.c
  group Middlewares/pjproject/pjsip/pjsua-lib
    ../Middlewares/pjproject/pjsip/src/pjsua-lib/: pjsua_acc.c pjsua_aud.c pjsua_call.c pjsua_core.c pjsua_dump.c pjsua_im.c pjsua_media.c pjsua_pres.c pjsua_vid.c
  group Middlewares/g7221
    ../Middlewares/pjproject/third_party/g7221/encode/: dct4_a.c encoder.c sam2coef.c
    ../Middlewares/pjproject/third_party/g7221/decode/: coef2sam.c dct4_s.c decoder.c
    ../Middlewares/pjproject/third_party/g7221/common/: basic_op.c common.c huff_tab.c tables.c
  group Middlewares/speex
    ../Middlewares/pjproject/third_party/speex/libspeex/: bits.c buffer.c cb_search.c exc_10_32_table.c fftwrap.c filterbank.c filters.c gain_table.c gain_table_lbr.c hexc_10_32_table.c hexc_table.c high_lsp_tables.c jitter.c kiss_fft.c kiss_fftr.c lpc.c lsp.c lsp_tables_nb.c ltp.c mdf.c modes.c modes_wb.c nb_celp.c preprocess.c quant_lsp.c resample.c sb_celp.c scal.c smallft.c speex.c speex_callbacks.c speex_header.c stereo.c vbr.c vorbis_psy.c vq.c window.c exc_5_64_table.c exc_5_256_table.c exc_8_128_table.c exc_10_16_table.c exc_20_32_table.c
  group Middlewares/resample
    ../Middlewares/pjproject/third_party/resample/src/: resamplesubs.c
  group Middlewares/gsm
    ../Middlewares/pjproject/third_party/gsm/src/: add.c code.c debug.c decode.c gsm_create.c gsm_decode.c gsm_destroy.c gsm_encode.c gsm_explode.c gsm_implode.c gsm_option.c gsm_print.c long_term.c lpc.c preprocess.c rpe.c short_term.c table.c
  group Middlewares/iLBC
    ../Middlewares/pjproject/third_party/ilbc/: anaFilter.c constants.c createCB.c doCPLC.c enhancer.c filter.c FrameClassify.c gainquant.c getCBvec.c helpfun.c hpInput.c hpOutput.c iCBConstruct.c iCBSearch.c iLBC_decode.c iLBC_encode.c LPCdecode.c LPCencode.c lsf.c packing.c StateConstructW.c StateSearchW.c syntFilter.c
  group Middlewares/CmBackTrace
    ../Middlewares/CmBacktrace/cm_backtrace/: cm_backtrace.c
    ../Middlewares/CmBacktrace/cm_backtrace/fault_handler/keil/: cmb_fault.S
software components: Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0
