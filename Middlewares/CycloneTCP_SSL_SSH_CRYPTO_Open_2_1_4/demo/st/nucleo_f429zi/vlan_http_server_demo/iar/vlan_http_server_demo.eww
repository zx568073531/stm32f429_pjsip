<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\vlan_http_server_demo.ewp</path>
  </project>
  <batchBuild/>
</workspace>


